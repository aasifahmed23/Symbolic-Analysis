Vdd 1 0 1.8
Vg1 4 0 0.8
Vg2 5 0 0.9
Vbias 7 0 0.7
MN1 2 4 6 0 N_18_MM L=5E-6 W=10E-6
MN2 3 5 6 0 N_18_MM L=5E-6 W=10E-6
MP3 2 2 1 1 P_18_MM L=5E-6 W=10E-6
MP4 3 2 1 1 P_18_MM L=5E-6 W=10E-6
MN5 6 7 0 0 N_18_MM L=5E-6 W=10E-6
