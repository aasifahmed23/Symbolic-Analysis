Vdd 1 0 1.8
Vb3 2 0 0.8
Vb2 4 0 1.2
Vin 6 0 1
MN1 5 6 0 0 N_18_MM L=5E-6 W=10E-6
MN2 3 4 5 0 N_18_MM L=5E-6 W=10E-6
MP3 3 2 1 1 P_18_MM L=5E-6 W=10E-6
